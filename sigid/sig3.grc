options:
  parameters:
    generate_options: no_gui
    id: sig3
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: sig.c32
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: flag3.wav
    repeat: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    gain: '0.5'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_ccf
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '22050'
    interp: audio_rate
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '960000'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_1, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_3, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_3, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
