options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: multi_tx
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '441000000'
  states: {}
- name: interpolation_rate
  id: variable
  parameters:
    value: samp_rate // 4800
  states: {}
- name: m17_deviation
  id: variable
  parameters:
    value: '800'
  states: {}
- name: resamp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: audio_rate / 2
    gain: samp_rate // audio_rate
    samp_rate: samp_rate
    width: audio_rate / 20
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate * 20
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: m17_deviation * 2 * math.pi / samp_rate
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate * 2
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '5'
    high_cutoff_freq: '2800'
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '5'
    high_cutoff_freq: '-200'
    interp: '1'
    low_cutoff_freq: '-2800'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: sigid.sigmf-data
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: flag8.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: paint.c32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.11'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '2'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(1.2 * audio_rate / wpm)
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: round(audio_rate / 45.45)
    type: byte
  states: {}
- name: blocks_rotator_cc_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-300e3 * 2 * math.pi / samp_rate'
  states: {}
- name: blocks_rotator_cc_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 400e3 * 2 * math.pi / samp_rate
  states: {}
- name: blocks_rotator_cc_1_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 200e3 * 2 * math.pi / samp_rate
  states: {}
- name: blocks_rotator_cc_1_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-100e3 * 2 * math.pi / samp_rate'
  states: {}
- name: blocks_rotator_cc_2
  id: blocks_rotator_cc
  parameters:
    phase_inc: 0e3 * 2 * math.pi / audio_rate
  states: {}
- name: blocks_rotator_cc_2_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 20e3 * 2 * math.pi / audio_rate
  states: {}
- name: blocks_rotator_cc_2_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-14e3 * 2 * math.pi / audio_rate'
  states: {}
- name: blocks_rotator_cc_2_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 12e3 * 2 * math.pi / audio_rate
  states: {}
- name: blocks_rotator_cc_2_0_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-8e3 * 2 * math.pi / audio_rate'
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: audio_rate
    sensitivity: 2 * math.pi
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0,)*90 + morse_table.morse_seq("This is VE3IRR   -   For signal identification challenge 6 the flag is itelilelcsemzpcc") + (0,)*91
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 1, 0, 1, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 1, 0, 0, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 1, 0, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 1, 1, 1, 1, 0, 0, 0, 1, 0, 1, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 1, 0, 1, 1, 1, 1, 1, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 0, 0, 0, 0, 1, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 1, 1, 1, 0, 1, 1, 1, 0, 0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 0, 1, 1, 1, 1, 0, 0, 0, 1, 1, 1, 1, 1, 0, 0, 0, 1, 0, 0, 1, 1]'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: flag3.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: flag4.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_1_0
  id: blocks_wavfile_source
  parameters:
    file: flag5.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: flag2.wav
    repeat: 'False'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[+1.0,+3.0,-1.0,-3.0]'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-85, 85]'
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '150'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: ccc
    width: '40'
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import morse_table
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12500'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    gain: '0.5'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_ccf
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: AM
  states: {}
- name: note_1
  id: note
  parameters:
    note: Upper sideband
  states: {}
- name: note_2
  id: note
  parameters:
    note: Lower sideband
  states: {}
- name: note_3
  id: note
  parameters:
    note: RTTY
  states: {}
- name: note_4
  id: note
  parameters:
    note: Narrowband FM
  states: {}
- name: note_6
  id: note
  parameters:
    note: CW
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate // 2
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // audio_rate
    taps: resamp_taps
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '22050'
    interp: '48000'
    type: fff
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    decim: '22050'
    interp: '48000'
    type: fff
  states: {}
- name: rational_resampler_xxx_3_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '22050'
    interp: '48000'
    type: fff
  states: {}
- name: rational_resampler_xxx_3_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '22050'
    interp: '48000'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: interpolation_rate
    interp: interpolation_rate
    ntaps: interpolation_rate*11+1
    samp_rate: interpolation_rate
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_rotator_cc_1_1_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0_0, '0']
- [band_pass_filter_0, '0', blocks_rotator_cc_2_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_rotator_cc_2_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_rotator_cc_2, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_add_xx_1, '0', rational_resampler_xxx_2, '0']
- [blocks_file_source_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_file_source_1, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_1, '0']
- [blocks_float_to_complex_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repeat_0, '0', root_raised_cosine_filter_1, '0']
- [blocks_repeat_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [blocks_rotator_cc_1, '0', blocks_add_xx_0, '0']
- [blocks_rotator_cc_1_0, '0', blocks_add_xx_0, '2']
- [blocks_rotator_cc_1_0_0, '0', blocks_add_xx_0, '3']
- [blocks_rotator_cc_1_1_0, '0', blocks_add_xx_0, '1']
- [blocks_rotator_cc_2, '0', blocks_add_xx_1, '0']
- [blocks_rotator_cc_2_0, '0', blocks_add_xx_1, '1']
- [blocks_rotator_cc_2_0_0, '0', blocks_add_xx_1, '2']
- [blocks_rotator_cc_2_0_0_0, '0', blocks_add_xx_1, '3']
- [blocks_rotator_cc_2_0_0_0_0, '0', blocks_add_xx_1, '4']
- [blocks_vco_c_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_1, '0', blocks_repeat_1, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_3_0, '0']
- [blocks_wavfile_source_0_1, '0', rational_resampler_xxx_3_0_0, '0']
- [blocks_wavfile_source_0_1_0, '0', rational_resampler_xxx_3_0_0_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_3, '0']
- [digital_chunks_to_symbols_xx_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_vco_c_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_rotator_cc_2_0_0_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_rotator_cc_1_0_0, '0']
- [rational_resampler_xxx_1, '0', blocks_rotator_cc_1, '0']
- [rational_resampler_xxx_2, '0', blocks_rotator_cc_1_0, '0']
- [rational_resampler_xxx_3, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_3_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_3_0_0, '0', blocks_float_to_complex_0_0, '0']
- [rational_resampler_xxx_3_0_0_0, '0', blocks_float_to_complex_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_rotator_cc_2_0_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [root_raised_cosine_filter_1, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
