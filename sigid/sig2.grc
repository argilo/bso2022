options:
  parameters:
    generate_options: no_gui
    id: sig2
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate * 2
    tau: '75e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: sig.c32
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: offset * (2 * math.pi / samp_rate)
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: flag2.wav
    repeat: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '12500'
    decim: '1'
    gain: '0.95'
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: samp_rate // (audio_rate * 2)
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '22050'
    interp: '48000'
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '960000'
  states: {}

connections:
- [analog_nbfm_tx_0, '0', low_pass_filter_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_3, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_3, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
