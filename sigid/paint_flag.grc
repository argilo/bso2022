options:
  parameters:
    author: argilo
    generate_options: no_gui
    id: paint_flag
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: db_range
  id: variable
  parameters:
    value: '60'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1000'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-fft_size'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: paint.c32
    type: complex
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.log(10**(db_range/20)) / fft_size
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.03'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: exp
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi * n / fft_size) ** 2 for n in range(fft_size)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_size)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: paint.png
    image_flip: '1'
    image_invert: '0'
    repeatmode: '0'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_transcendental_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_multiply_xx_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [paint_image_source_0, '0', blocks_uchar_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
