options:
  parameters:
    author: argilo
    generate_options: qt_gui
    id: usrp_tx
    output_language: python
    title: BSides Ottawa Challenges
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '441000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '90'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '5760000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: final.c32
    repeat: 'True'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
