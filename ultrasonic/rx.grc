options:
  parameters:
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Ultrasonic receiver
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '19000'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (samp_rate // decimation) * 0.4
    gain: '1.0'
    samp_rate: samp_rate
    width: (samp_rate // decimation) * 0.2
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '75'
  states: {}
- name: sync_word
  id: variable
  parameters:
    value: '[0xd3, 0x91]'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_1
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"0101010101010101" + "".join(f"{b:08b}" for b in sync_word)'
    tagname: start
    threshold: '2'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, tag='start'):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Message Printer',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.tag_name = tag
              self.reset()

          def reset(self):
              self.current_byte = 0
              self.current_bits = 0

          def work(self, input_items, output_items):
              rel_offsets = set()
              for tag in self.get_tags_in_window(0, 0, len(input_items[0])):
                  if pmt.to_python(tag.key) == self.tag_name:
                      rel_offsets.add(tag.offset - self.nitems_read(0))
              for i, bit in enumerate(input_items[0]):
                  if i in rel_offsets:
                  	self.reset()

                  self.current_byte = (self.current_byte << 1) | bit
                  self.current_bits += 1

                  if self.current_bits == 8:
                      c = chr(self.current_byte)
                      if c.isprintable() or c == "\n":
                          print(c, end="", flush=True)
                      self.reset()
                  
              return len(input_items[0])
    tag: '"start"'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: decimation
    samp_rate: samp_rate
    taps: lp_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate // decimation
    type: float
    ymax: math.pi
    ymin: '-math.pi'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_correlate_access_code_tag_xx_1, '0', epy_block_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_tag_xx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gfsk_demod_0, '0']

metadata:
  file_format: 1
